# IAR project W5500+BORD.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EMB_FLASH; STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: Libraries\chip\Stm32f1xx\; Libraries\chip\Stm32f1xx\CMSIS\CM3\; Libraries\chip\Stm32f1xx\CMSIS\CM3\DeviceSupport\ST\STM32F10x\; Libraries\chip\Stm32f1xx\STM32F10x_StdPeriph_Driver\inc\; Libraries\chip\Stm32f1xx\STM32F10x_StdPeriph_Driver\src\; Libraries\chip\Stm32f1xx\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\iar
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: W5500+BORD.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f103xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main.c
  group CMSIS
    Libraries/chip/Stm32f1xx/CMSIS/CM3/CoreSupport/: core_cm3.c
    Libraries/chip/Stm32f1xx/: core_cm3.h
    Libraries/chip/Stm32f1xx/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
    Libraries/chip/Stm32f1xx/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h stm32f10x_conf.h system_stm32f10x.c system_stm32f10x.h
  group SPL/inc
    Libraries/chip/Stm32f1xx/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group SPL/src
    Libraries/chip/Stm32f1xx/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
